# Keil uVision project 51_Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\device;..\drivers;..\src;..\src\Buzzer;..\src\LED;..\src\Key;..\src\Nixie;..\src\ADC;..\src\PWM;..\src\Timer;..\src\UART;..\src\Motor;..\src\I2C;..\src\NTC;..\src\Factory;..\src\Labs;..\src\EXTI;..\src\Labs\LedModelLab;..\src\Labs\BuzzerSequenceLab;..\src\Labs\TimerTickLab;..\src\DHT11;..\src\Labs\BuzzerToneLab;..\src\Labs\AlarmLab;..\src\Labs\BuzzerArrayLab;..\src\Matrix;..\src\Labs\LedPwmLab;..\src\Labs\AdcMotorLab;..\src\Labs\KeyLedLab;..\src\Labs\KeyOutputLab;..\src\Labs\LedBasicLab;..\src\Labs\LedCycleLab;..\src\Labs\LedFlipLab;..\src\Labs\LedFlowLab;..\src\Labs\NtcTestLab;..\src\Labs\RtcDisplayLab;..\src\Labs\UartDeviceLab;..\src\Labs\MatrixKeyLab;..\src\Labs\PotMotorLab;..\Dirvers;..\src\SpiOled;..\src\SelfTest;..\src\Labs\AdcModeLab;..\src\Labs\UartCommand;..\src\Labs\AdcNixieLab;..\src\Labs\NtcDisplayLab;..\src\Labs\TempAlarmLab
  asm include: ..\device;..\drivers;..\src;..\src\Buzzer;..\src\ADC;..\src\Nixie;..\src\Key;..\src\Timer;..\src\PWM;..\src\UART;..\src\LED;..\src\Motor;..\src\Factory;..\src\DHT11;..\src\Labs;..\src\Labs\BuzzerToneLab;..\src\Labs\AlarmLab;..\src\Labs\BuzzerArrayLab;..\src\Matrix;..\src\Labs\LedPwmLab;..\src\Labs\AdcMotorLab;..\src\Labs\BuzzerSequenceLab;..\src\Labs\KeyLedLab;..\src\Labs\KeyOutputLab;..\src\Labs\LedBasicLab;..\src\Labs\LedCycleLab;..\src\Labs\LedFlipLab;..\src\Labs\LedFlowLab;..\src\Labs\LedModelLab;..\src\Labs\NtcTestLab;..\src\Labs\RtcDisplayLab;..\src\Labs\TimerTickLab;..\src\Labs\UartDeviceLab;..\src\Labs\MatrixKeyLab;..\src\Labs\PotMotorLab;..\src\EXTI;..\src\I2C;..\src\NTC;..\src\SpiOled;..\src\SelfTest;..\src\Labs\AdcModeLab;..\src\Labs\UartCommand;..\src\Labs\AdcNixieLab;..\src\Labs\NtcDisplayLab;..\src\Labs\TempAlarmLab
  link misc: REMOVEUNUSED
  group User
    ../src/: main.c
  group BSP
    ../src/LED/: LED.c
    ../src/Motor/: Motor.c
    ../src/Buzzer/: Buzzer.c
    ../src/Key/: Key.c
    ../src/Timer/: Timers.c
    ../src/I2C/: IIC.c
    ../src/EXTI/: EXTIS.c
    ../src/UART/: UARTS.c
    ../src/PWM/: PWM.c
    ../src/DHT11/: DHT11.c
    ../src/Matrix/: MatrixKey.c
    ../src/ADC/: ADCS.c
    ../src/NTC/: NTC.c
    ../src/Factory/: Factory.c
    ../src/Nixie/: Nixie.c
    ../src/SpiOled/: SpiOled.c
    ../src/SelfTest/: SelfTest.c
  group Labs
    ../src/Labs/LedFlowLab/: LedFlowLab.c
    ../src/Labs/LedModelLab/: LedModelLab.c
    ../src/Labs/BuzzerSequenceLab/: BuzzerSequenceLab.c
    ../src/Labs/TimerTickLab/: TimerTickLab.c
    ../src/Labs/LedBasicLab/: LedBasicLab.c
    ../src/Labs/KeyLedLab/: KeyLedLab.c
    ../src/Labs/LedFlipLab/: LedFlipLab.c
    ../src/Labs/BuzzerToneLab/: BuzzerToneLab.c
    ../src/Labs/AlarmLab/: AlarmLab.c
    ../src/Labs/BuzzerArrayLab/: BuzzerArrayLab.c
    ../src/Labs/LedPwmLab/: LedPwmLab.c
    ../src/Labs/AdcMotorLab/: AdcMotorLab.c
    ../src/Labs/KeyOutputLab/: KeyOutputLab.c
    ../src/Labs/LedCycleLab/: LedCycleLab.c
    ../src/Labs/NtcTestLab/: NtcTestLab.c
    ../src/Labs/RtcDisplayLab/: RtcDisplayLab.c
    ../src/Labs/UartDeviceLab/: UartDeviceLab.c
    ../src/Labs/MatrixKeyLab/: MatrixKeyLab.c
    ../src/Labs/PotMotorLab/: PotMotorLab.c
    ../src/Labs/AdcModeLab/: AdcModeLab.c
    ../src/Labs/UartCommand/: UartCommand.c
    ../src/Labs/AdcNixieLab/: AdcNixieLab.c
    ../src/Labs/NtcDisplayLab/: NtcDisplayLab.c
    ../src/Labs/TempAlarmLab/: TempAlarmLab.c
  group Drivers
    ../drivers/: ADC.c ADC_Isr.c Compare.c Compare_Isr.c Delay.c EEPROM.c Exti.c Exti_Isr.c GPIO.c GPIO_Isr.c I2C.c I2C_Isr.c NVIC.c oled.c Soft_I2C.c Soft_UART.c SPI.c SPI_Isr.c STC8G_PCA.c STC8G_PCA_Isr.c STC8G_PWM15bit.c STC8G_PWM15bit_Isr.c STC8H_DMA.c STC8H_PWM.c STC8H_PWM_Isr.c Timer.c Timer_Isr.c UART.c UART_Isr.c WDT.c STC8H_RTC.c
  group OS
    ../OS/: Conf_tny.A51 RTX51TNY.LIB
